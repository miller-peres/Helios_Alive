# Keil uVision project instramed.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2114 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 9.2 +hex
  c flags: Optim=4 wLevel=2
  c include: c:\instramed
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group sources
    ./: Startup.s Time.cpp Retarget.cpp irq.cpp timer.cpp global.cpp main.cpp fsm_master.cpp led.cpp botao.cpp alarm.cpp spo2.cpp zigbee.cpp vic.cpp interrupt.cpp
